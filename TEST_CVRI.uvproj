# Keil uVision project TEST_CVRI.uvproj, settings and files
target TEST_CVRI (MCS-51)
  device: AT89F52 Atmel
  cpu: IRAM(0 - 0xFF) IROM(0 - 0x1FFF) CLOCK(24000000)
  output: TEST_CVRI +hex
  c flags: Optimize=9 SizeSpeed=1
  group BIT1618C
    ./: BITEK.C COMMON.C MAIN.C MCU.C OSD.C POR.C SARADC.C TIMER.C VP.C
